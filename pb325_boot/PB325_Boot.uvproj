# Keil uVision project PB325_Boot.uvproj, settings and files
target Boot (ARM-ADS)
  device: LM3S5956 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(80000000) CPUTYPE("Cortex-M3")
  output: PB325_Boot +hex
  c flags: Optim=3 OneElfS=1
  c include: ..\litecore;..\litecore\arch\cm3\lm3s;.\config;.\elmfat
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group litecore
    ../litecore/: litecore.c
    ../litecore/arch/cm3/lm3s/driverlib/rvmdk/: driverlib-cm3.lib
    ./: Startup.s
  group app
    ./: main.c
  group elmfat
    ./elmfat/: diskio.c ff.c
