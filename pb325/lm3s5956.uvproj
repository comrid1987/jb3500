# Keil uVision project lm3s5956.uvproj, settings and files
target LM3S5956 (ARM-ADS)
  device: LM3S5951 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: pb325 +hex
  AfterMake: #Karm\armcc\bin\fromelf.exe --bin -o $l@l.bin #l
  c flags: Optim=1 OneElfS=1
  c include: ..\litecore;.\config;.\app;..\litecore\arch\cm3\lm3s
  memory RVCT4: ROM 0x4000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group litecore
    ../litecore/: litecore.c
    ../litecore/arch/cm3/lm3s/: start_rvds.S
    ../litecore/arch/cm3/: context_rvds.S
    ../litecore/arch/cm3/lm3s/driverlib/rvmdk/: driverlib-cm3.lib
    ./config/: TCP_CM3.lib
  group app
    ./app/: main.c gd5100_code.c gw3761.c gw3761_fn01.c gw3761_fn040A.c gw3761_fn05.c gw3761_fn09.c gw3761_fn0C.c gw3761_fn0D.c gw3761_fn0E.c gw3761_fn0F.c gw3761_fn10.c upcomm.c alarm.c acm.c meter.c para.c data.c display.c
